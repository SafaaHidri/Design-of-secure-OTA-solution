# IAR project boot.ewp, settings and files
configuration STM32L053R8_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L053xx; USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: boot.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L053R8_NUCLEO
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Example/EWARM
    ./: startup_stm32l053xx.s
  group Example/User
    ../Src/: boot_app.c comm_pro.c flash_if.c main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
    ../Inc/: boot_app.h com_pro.h flash.h
